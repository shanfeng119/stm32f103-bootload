# Keil uVision project project.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F103RF STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80BFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: boot +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o Flash\OBJ\boot.bin Flash\OBJ\boot.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_XL
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\User\bsp\inc;..\..\User\bsp;..\..\User\fonts;..\..\User;..\..\User\FatFS\src;..\..\User\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ../../User/: main.c stm32f10x_it.c
  group BSP
    ../../User/bsp/: bsp.c iap.c YModem.c upload.c download.c dwt.c iwdg.c spi_flash.c util.c md5.c led.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_iwdg.c stm32f10x_dbgmcu.c
  group CMSIS
    ../../User/: system_stm32f10x.c
